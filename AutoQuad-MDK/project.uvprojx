# Keil uVision project project.uvprojx, settings and files
target AutoQuad (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AutoQuad-mdk +hex
  AfterMake: fromelf --bin !L --output AutoQuad-mdk.bin
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __FPU_PRESENT = 1,__FPU_USED = 1,USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4,__CC_ARM,BOARD_VERSION=8,BOARD_REVISION=6
  c misc: --gnu --c99
  c include: applications;.;aq_can;.;aq_disk;.;aq_drivers;.;aq_hilsim\include;aq_math;.;aq_mavlink\include\autoquad;aq_mavlink\include;aq_mavlink\include\common;aq_mavlink;aq_radio;.;aq_src;.;aq_targets;.;aq_usb;drivers;dspLib;Libraries\STM32F4xx_StdPeriph_Driver\inc;Libraries\CMSIS\ST\STM32F4xx\Include;Libraries\CMSIS\Include;rt-thread-2.1.0\include;rt-thread-2.1.0\libcpu\arm\cortex-m4;rt-thread-2.1.0\libcpu\arm\common;rt-thread-2.1.0\components\drivers\include;rt-thread-2.1.0\components\drivers\include;rt-thread-2.1.0\components\drivers\include;.\ctrl_libraries\Filter;.\easyflash\inc;.\easyflash\plugins\types;.\easyflash\plugins
  memory RVCT4: ROM 0x8020000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\autoquad.sct
  link misc: --keep *.o(.rti_fn.*)
  group Applications
    applications/: application.c cpuusage.c startup.c
    ./applications/: app_easyflash.c
  group AQ_can
    aq_can/: can.c canCalib.c canOSD.c canSensors.c canUart.c
  group AQ_disk
    aq_disk/: ff.c sdio.c
  group AQ_drivers
    aq_drivers/: 1wire.c adc.c analog.c aq_serial.c cyrf6936.c digital.c eeprom.c ext_irq.c flash.c fpu.c hmc5983.c max21100.c mpu6000.c ms5611.c pwm.c rcc.c rtc.c spi.c ublox.c
  group AQ_math
    aq_math/: algebra.c rotations.c srcdkf.c
  group AQ_mavlink
    aq_mavlink/: aq_mavlink.c
  group AQ_radio
    aq_radio/: dsm.c futaba.c grhott.c mlinkrx.c ppm.c radio.c spektrum.c
  group AQ_src
    aq_src/: alt_ukf.c aq_timer.c calib.c comm.c command.c compass.c config.c control.c d_imu.c esc32.c filer.c geo_mag_declination.c gimbal.c gps.c imu.c logger.c motors.c nav.c nav_ukf.c pid.c rc.c run.c signaling.c supervisor.c telem_sPort.c telemetry.c util.c
    ./aq_src/: LowPassFilterFloat.c fuzzyPID.c
  group AQ_usb
    aq_usb/: usb.c usb_bsp.c usb_core.c usbd_desc.c usbd_storage_msd.c usbd_cdc_msc_core.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c usbd_req.c usbd_core.c usbd_ioreq.c usb_dcd_int.c usb_dcd.c
  group Drivers
    drivers/: board.c stm32f4xx_it.c usart.c gpio.c
  group dsplib
    dspLib/: arm_cortexM4lf_math.lib
  group STM32_StdPeriph
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
    Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
    Libraries/CMSIS/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group Kernel
    rt-thread-2.1.0/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    rt-thread-2.1.0/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    rt-thread-2.1.0/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    rt-thread-2.1.0/components/drivers/misc/: pin.c
    rt-thread-2.1.0/components/drivers/serial/: serial.c
    rt-thread-2.1.0/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group easyflash
    ./easyflash/src/: easyflash.c ef_env.c ef_env_wl.c ef_iap.c ef_log.c ef_utils.c
    ./easyflash/port/: ef_port.c
